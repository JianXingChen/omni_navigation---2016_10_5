# Keil uVision project STM32F4.uvproj, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F405VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\Mylib;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c Remote.c CAN2.c
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c startup_stm32f4xx.s
  group Debug
    ../User/: led.c USART3.c
  group Sys
    ../User/: sys.c delay.c clock.c
  group Sensor
    ../User/: imu.c mpu6050_driver.c mpu6050_i2c.c mpu6050_interrupt.c
  group Chassis
    ../User/: Chassis_Control.c Wheel_Speed.c
